<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>Bode</key>
<param><key>id</key><value>Bode_0</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>Transfer_Function_Numerator</key>
<param><key>id</key><value>Transfer_Function_Numerator_0</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0_4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>Transfer_Function_Denominator</key>
<param><key>id</key><value>Transfer_Function_Denominator_0</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<connection><source_block_id>Transfer_Function_Denominator_0</source_block_id><sink_block_id>Bode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transfer_Function_Numerator_0</source_block_id><sink_block_id>Bode_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>Transfer_Function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0_1</source_block_id><sink_block_id>Transfer_Function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0_0</source_block_id><sink_block_id>Transfer_Function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0_2</source_block_id><sink_block_id>Transfer_Function_Numerator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>const_source_x_0_3</source_block_id><sink_block_id>Transfer_Function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0_4</source_block_id><sink_block_id>Transfer_Function_Denominator_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
